# Keil uVision project doubleKeyTest.uvproj, settings and files
target doubleKeyTest (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: doubleKeyTest_HEX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source
    ./source/: MAIN.C nrf24l01p.c delay.c UART.C
